# Keil uVision project Cool.uvprojx, settings and files
target Cool (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cool +hex
  AfterMake: fromelf --bin --output ./cool.bin ./Objects/cool.axf
  AfterMake: ../../Tools/IAPTool/addcrc32/addcrc32 ./cool.bin ./cool_crc.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,PRJ_IAP
  c include: ..\..\Stm32F1xxHal_V160\Drivers\CMSIS\Include;..\..\Stm32F1xxHal_V160\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Stm32F1xxHal_V160\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Source\Common;..\..\Source\Common\Commu;..\..\Source\Common\Data;..\..\Source\Common\Dev;..\..\Source\Boards\Cool;..\..\Source\Common\DownLo
  memory RVCT4: ROM 0x8004000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32/CMSIS
    ../../Stm32F1xxHal_V160/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../Stm32F1xxHal_V160/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group STM32/HAL
    ../../Stm32F1xxHal_V160/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Common/Data
    ../../Source/Common/Data/: Bits.h Buffer.c Buffer.h Datatypes.h Message.c Message.h
  group Common/Commu
    ../../Source/Common/Commu/: Console.c Console.h Host.c Host.h Uart.h Uart.c UartF103CB.h
  group Common/Dev
    ../../Source/Common/Dev/: Gpio.c Gpio.h Timer.c Timer.h AlgorithmPID.c AlgorithmPID.h Pwm.c Pwm.h
  group Boards/Cool
    ../../Source/Boards/Cool/: Board.c Board.h Interrupts.c Main.c Cool.c Cool.h LedFans.c LedFans.h OneWire.c OneWire.h DS18B20.c DS18B20.h HostCool.c
  group Common/DownLo
    ../../Source/Common/DownLo/: SerialDownLoad.c
