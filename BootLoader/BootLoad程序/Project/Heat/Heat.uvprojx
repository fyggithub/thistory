# Keil uVision project Heat.uvprojx, settings and files
target Heat (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Heat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Stm32F1xxHal_V160\Drivers\CMSIS\Include;..\..\Stm32F1xxHal_V160\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Stm32F1xxHal_V160\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Source\Common;..\..\Source\Common\Commu;..\..\Source\Common\Data;..\..\Source\Common\Dev;..\..\Source\Boards\Heat
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STM32/CMSIS
    ../../Stm32F1xxHal_V160/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../Stm32F1xxHal_V160/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group STM32/HAL
    ../../Stm32F1xxHal_V160/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c
  group Common/Data
    ../../Source/Common/Data/: Bits.h Buffer.c Buffer.h Datatypes.h Message.c Message.h
  group Common/Commu
    ../../Source/Common/Commu/: Console.c Console.h Host.c Host.h Uart.h Uart.c UartF103CB.h delayus.c
  group Common/Dev
    ../../Source/Common/Dev/: Gpio.c Gpio.h Timer.c Timer.h AlgorithmPID.c AlgorithmPID.h Pwm.c Pwm.h
  group Boards/Heat
    ../../Source/Boards/Heat/: Board.c Heat.c Interrupts.c Main.c SpiHeat.c TLC2543.c WaveTools.c Led.c HostHeat.c
