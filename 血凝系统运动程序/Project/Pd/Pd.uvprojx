# Keil uVision project Pd.uvprojx, settings and files
target Pd (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Pd
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c include: ..\..\Source\Common;..\..\Source\Common\Commu;..\..\Source\Common\Data;..\..\Source\Common\Dev;..\..\Stm32F0xxHal_V190\Drivers\CMSIS\Include;..\..\Stm32F0xxHal_V190\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\Stm32F0xxHal_V190\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\Source\Boards\Pd
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STM32/CMSIS
    ../../Stm32F0xxHal_V190/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../../Stm32F0xxHal_V190/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051x8.s
  group STM32/HAL
    ../../Stm32F0xxHal_V190/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_spi.c stm32f0xx_hal_rcc_ex.c
  group Common/Data
    ../../Source/Common/Data/: Bits.h Buffer.c Buffer.h Datatypes.h Message.c Message.h
  group Common/Commu
    ../../Source/Common/Commu/: Console.c Console.h Uart.h Spi.h Spi.c Uart.c
  group Common/Dev
    ../../Source/Common/Dev/: Gpio.c Gpio.h
  group Boards/Pd
    ../../Source/Boards/Pd/: HostPd.c Board.c Interrupts.c Main.c AD7689.c Pd.c Led.c delayus.c BoardHost.c BoardHost.h LedTest.c
