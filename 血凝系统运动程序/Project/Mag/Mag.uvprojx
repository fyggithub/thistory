# Keil uVision project Mag.uvprojx, settings and files
target Mag (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051K6Ux STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Mag
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c include: ..\..\Source\Common;..\..\Source\Common\Commu;..\..\Source\Common\Data;..\..\Source\Common\Dev;..\..\Stm32F0xxHal_V190\Drivers\CMSIS\Include;..\..\Stm32F0xxHal_V190\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\Stm32F0xxHal_V190\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\Source\Boards\Mag
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STM32/CMSIS
    ../../Stm32F0xxHal_V190/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../../Stm32F0xxHal_V190/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051x8.s
  group STM32/HAL
    ../../Stm32F0xxHal_V190/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_uart.c stm32f0xx_hal_usart.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart_ex.c
  group Common/Data
    ../../Source/Common/Data/: Bits.h Buffer.c Buffer.h Datatypes.h Message.c Message.h
  group Common/Commu
    ../../Source/Common/Commu/: Console.c Console.h Spi.c Spi.h Uart.c Uart.h UartF051X8.h
  group Common/Dev
    ../../Source/Common/Dev/: Gpio.c Gpio.h Timer.c Timer.h
  group Boards/Mag
    ../../Source/Boards/Mag/: Board.c Board.h Main.c Interrupts.c Mag.c Mag.h AD7928.c AD7928.h HostMag.c BoardHost.c
