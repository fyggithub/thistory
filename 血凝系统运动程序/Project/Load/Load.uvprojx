# Keil uVision project Load.uvprojx, settings and files
target Load (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Load
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Stm32F1xxHal_V160\Drivers\CMSIS\Include;..\..\Stm32F1xxHal_V160\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Stm32F1xxHal_V160\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Source\Common;..\..\Source\Common\Commu;..\..\Source\Common\Data;..\..\Source\Common\Dev;..\..\Source\Boards\Load
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32/CMSIS
    ../../Stm32F1xxHal_V160/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../Stm32F1xxHal_V160/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group STM32/HAL
    ../../Stm32F1xxHal_V160/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_crc.c
  group Common/Data
    ../../Source/Common/Data/: Bits.h Buffer.c Buffer.h Datatypes.h Message.c Message.h Config.c Config.h
  group Common/Commu
    ../../Source/Common/Commu/: Console.c Console.h Host.c Host.h Uart4Axis.h Uart.h Uart.c Spi.c Spi.h
  group Common/Dev
    ../../Source/Common/Dev/: Gpio.c Gpio.h Timer.c Timer.h Fram.h FramFM25CL64B.c Pulse.h StepMotor.c StepMotor.h Pulse4Axis.c AccelerateTable.c AccelerateTable.h
  group Boards/Load
    ../../Source/Boards/Load/: Board.c Board.h Main.c Interrupts.c HostLoad.c HostLoad.h Load.c Load.h stateReady.c stateReset.c SlideState.c SlideState.h ConfigLoad.c ConfigLoad.h SendResultCode.c SendResultCode.h
